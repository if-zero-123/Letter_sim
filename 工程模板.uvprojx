# Keil uVision project 工程模板.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,SHELL_CFG_USER=\"shell_cfg_user.h\"
  c include: .\user;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./user/: main.c stm32f10x_it.c
  group Cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group ST_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_tim.c stm32f10x_usart.c
  group APP
    ./APP/: LED.C systick.c USART.C shell_cmd_list.c shell_companion.c shell_ext.c shell_cfg.h shell_ext.h shell_port.c shell_cfg_user.h cmd_demo.c
    ../../一代一路/程序代码（文泉）/程序代码（文泉）/9 USART/APP/: shell.c shell.h LED.H systick.h USART.H
software components: CMSIS:CORE 5.4.0
